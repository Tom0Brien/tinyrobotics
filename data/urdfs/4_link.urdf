Commit message: Move init tree/dynamics to Parser

File: data/urdfs/4_link.urdf (robot description, URDF)
Before this commit: robot 4_link, 5 links, 4 joints
Joints:
- joint link_3: parent link_1 -> link_2
